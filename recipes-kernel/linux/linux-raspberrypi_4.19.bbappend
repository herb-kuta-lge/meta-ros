# Copyright (c) 2019 LG Electronics, Inc.

SRC_URI_append = " \
    file://governor.cfg \
    file://ntfs.cfg \
    file://zram.cfg \
"
