# Metadata common to all ROS images.
#
# Copyright (c) 2019 LG Electronics, Inc.

# XXX (add description)
IMAGE_FEATURES[validitems] += "ros-implicit-workspace"
COMPLEMENTARY_GLOB[ros-implicit-workspace] = "*-implicitworkspace"
